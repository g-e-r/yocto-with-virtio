FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI:append = " file://virtio-i2c-spi.cfg"
